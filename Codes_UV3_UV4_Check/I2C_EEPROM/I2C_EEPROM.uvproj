# Keil uVision project I2C_EEPROM.uvproj, settings and files
target Demo (ARM-ADS)
  device: LPC2148 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: I2C_EEPROM
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Start Up
    ./: Startup.s
  group Source Group
    ./: UART_Utility.c I2C_EEPROM.c
