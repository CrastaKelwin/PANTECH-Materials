# Keil uVision project LED_Switch.uvproj, settings and files
target LED_Switch ()
  device: LPC2148 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: LED_Switch +hex
  group Start Up
    ./: Startup.s
  group Source Group
    ./: LED_Switch.c
  group Documentation
    ./: Abstract
