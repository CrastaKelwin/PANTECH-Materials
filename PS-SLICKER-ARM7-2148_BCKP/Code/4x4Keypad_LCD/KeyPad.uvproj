# Keil uVision project KeyPad.uvproj, settings and files
target KeyPad_LCD ()
  device: LPC2138 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: KeyPad_Demo_Test +hex
  group Start Up
    ./: Startup.s
  group Source Code
    ./: Demo_KeyPad.c
  group Obj
    ./Out/: KeyPad.obj LCD Demo.obj
