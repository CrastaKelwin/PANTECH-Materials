# Keil uVision project 4x4KeyPad.uvproj, settings and files
target Demo ()
  device: LPC2148 Philips
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Keypad +hex
  group Start Up
    ./: Startup.s
  group Source Code
    ./: KeyPad.c
